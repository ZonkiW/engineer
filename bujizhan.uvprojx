# Keil uVision project bujizhan.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: bujizhan
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\BSP;.\COMMON;.\CORE;.\STLibraries\inc;.\TASK;.\USER;.\HARDWARE\timer;.\SYSTEM;.\HARDWARE\led;.\HARDWARE
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./USER/: stm32f4xx_it.c main.c system_stm32f4xx.c
  group STLibraries
    ./STLibraries/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group CORE
    ./CORE/: startup_stm32f40_41xxx.s
  group COMMON
    ./COMMON/: BIANLIANG_Definition.c
  group SYSTEM
    ./SYSTEM/: delay.c pwm.c can1.c can2.c pid.c timer.c ramp.c ShooterMControlLoop.c YAOKONG_Configuration.c CHASSIS_Motor.c Pitch_Yaw_Motor.c GYRO_Configuration.c Encoder_Process.c TASK_Init.c UP_DOWN_Motor.c FOWARD_BACK_MOTOR.c PAW_MOTOR.c single_double_handle.c timer2.c Aux_Function.c CM_PID.c DATA_SEND_HANDLE.c user_data_usart.c RMLib.lib user_data_handle.c
